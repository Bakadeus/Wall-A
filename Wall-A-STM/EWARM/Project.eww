<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Wall-A-STM.ewp</path>
  </project>
  <batchBuild />
</workspace>
